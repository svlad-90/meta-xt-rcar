RENESAS_BSP_URL = "git://github.com/otyshchenko1/linux.git;protocol=https"
SRC_URI[sha256sum] = "a4e7c6f4e35179a9600306c9a877f7223032f7b9b5158a2d2f2d0d23227984bb"

BRANCH = "virtio_devel_next3"
SRCREV = "${AUTOREV}"
LINUX_VERSION = "6.2.0-rc4"
